## counting/Kconfig
```kconfig
menuconfig EXAMPLES_COUNTING
	bool "counting"
	default n
	---help---
		Enable support for counting
```
